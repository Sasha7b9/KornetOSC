# Keil uVision project DeviceOSC.uvprojx, settings and files
target Device (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F437ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: FPGA
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F437xx
  c misc: --diag_suppress=161
  c include: .\src;.\src\libs\CMSIS;.\src\libs\HAL;..\libs\common;..\libs\STM32Cube_F4\Drivers\STM32F4xx_HAL_Driver\Inc;..\libs\STM32Cube_F4\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\libs\STM32Cube_F4\Drivers\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6776
  group libs/CMSIS
    ./src/libs/CMSIS/: startup_stm32f437xx.s system_stm32f4xx.c
  group libs/HAL
    ../libs/STM32Cube_F4/Drivers/STM32F4xx_HAL_Driver/Inc/: stm32f4xx_hal.h stm32f4xx_hal_gpio.h stm32f4xx_hal_adc.h stm32f4xx_hal_cortex.h stm32f4xx_hal_adc_ex.h stm32f4xx_hal_dma.h stm32f4xx_hal_dac.h stm32f4xx_hal_dac_ex.h stm32f4xx_hal_pcd.h stm32f4xx_hal_rcc.h stm32f4xx_hal_spi.h stm32f4xx_ll_usb.h stm32f4xx_hal_sram.h stm32f4xx_hal_uart.h stm32f4xx_ll_fmc.h stm32f4xx_hal_nor.h stm32f4xx_ll_fsmc.h stm32f4xx_hal_flash.h stm32f4xx_hal_flash_ex.h stm32f4xx_ll_tim.h stm32f4xx_hal_tim_ex.h
    ../libs/STM32Cube_F4/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_gpio.c stm32f4xx_hal_adc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_rcc.c stm32f4xx_hal_spi.c stm32f4xx_ll_usb.c stm32f4xx_hal_sram.c stm32f4xx_hal_uart.c stm32f4xx_ll_fmc.c stm32f4xx_hal_nor.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
    ./src/libs/HAL/: stm32f4xx_hal_conf.h stm32f4xx_it.c stm32f4xx_it.h stm32f4xx_hal_msp.cpp
  group src
    ./src/: defines.h main.cpp main.h Log.cpp Log.h Device.cpp Device.h
  group Display
    ./src/Display/: Display.cpp Display.h Painter.cpp Painter.h Grid.cpp Grid.h PainterData.cpp PainterData.h TypeSymbols.h
  group FPGA
    ./src/FPGA/: FPGA.cpp FPGA.h FPGA_Types.h Storage.cpp Storage.h AD9286.cpp AD9286.h
  group Hardware
    ./src/Hardware/: FSMC.cpp FSMC.h Hardware.cpp Hardware.h Timer.cpp Timer.h GPIO.cpp GPIO.h FLASH.cpp FLASH.h
  group Hardware/stm32
    ../libs/common/Hardware/stm32/: stm32.cpp stm32.h
    ../libs/common/Hardware/stm32/4XX/: stm437.cpp stm437.h Timer4XX.cpp Timer4XX.h
  group Keyboard
    ./src/Keyboard/: Buttons.h
  group Menu
    ./src/Menu/: Menu.cpp Menu.h MenuControls.h MenuControls.cpp
  group Menu/Pages
    ./src/Menu/Pages/: PageTrig.cpp PageChannel.cpp PageDisplay.cpp PageService.cpp PageTester.cpp
  group Multimeter
    ./src/Multimeter/: Multimeter.cpp Multimeter.h
  group Osci
    ./src/Osci/: Osci.cpp Osci.h
  group Settings
    ./src/Settings/: Settings.cpp Settings.h SettingsTypes.h
  group Tester
    ./src/Tester/: Tester.cpp Tester.h
  group Utils
    ./src/Utils/: CommonFunctions.cpp CommonFunctions.h Debug.cpp Debug.h MathOSC.cpp MathOSC.h Decoder.cpp Decoder.h
    ../libs/common/Utils/: Math.h Math.cpp
