# Keil uVision project OSC-Open.uvprojx, settings and files
target Panel (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F429VITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: PanelOSC
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 v6Lto=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F429xx, DEBUG
  c include: ..\Panel\src;..\Panel\src\libs\CMSIS;..\Panel\src\libs\HAL;..\common\libs\STM32Cube_F4\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\common\libs\STM32Cube_F4\Drivers\STM32F4xx_HAL_Driver\Inc;..\common\libs\STM32Cube_F4\Drivers\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group libs/CMSIS
    ../common/libs/STM32Cube_F4/Drivers/CMSIS/Device/ST/STM32F4xx/Include/: stm32f4xx.h stm32f429xx.h
    ../Panel/src/libs/CMSIS/: startup_stm32f429xx.s system_stm32f4xx.c
  group libs/HAL
    ../common/libs/STM32Cube_F4/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_gpio.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_dma2d.c
    ../common/libs/STM32Cube_F4/Drivers/STM32F4xx_HAL_Driver/Inc/: stm32f4xx_hal.h stm32f4xx_hal_cortex.h stm32f4xx_hal_dma.h stm32f4xx_hal_gpio.h stm32f4xx_hal_tim.h stm32f4xx_hal_tim_ex.h stm32f4xx_hal_pwr.h stm32f4xx_hal_pwr_ex.h stm32f4xx_hal_rcc.h stm32f4xx_hal_rtc_ex.h stm32f4xx_hal_ltdc.h stm32f4xx_hal_dma2d.h
    ../Panel/src/libs/HAL/: stm32f4xx_hal_conf.h stm32f4xx_it.c stm32f4xx_it.h
  group src
    ../Panel/src/: defines.h Log.cpp Log.h
    ./src/: main.cpp Panel.h Panel.cpp
  group Display
    ../Panel/src/Display/: Display.cpp Display.h DisplayTypes.h Painter.cpp Painter.h PainterText.cpp PainterSTM429.cpp Colors.cpp Colors.h PainterTextSTM429.cpp
  group Display/font
    ../Panel/src/Display/font/: Font.h font5.inc font8.inc fontUGO.inc fontUGO2.inc Font.cpp
  group Hardware
    ../Panel/src/Hardware/: FSMC.cpp FSMC.h CPU.cpp CPU.h CPU_IT.cpp Controls.h Keyboard.cpp Keyboard.h LTDC.cpp LTDC.h
  group Hardware/stm32
    ../Panel/src/Hardware/stm32/: stm32.cpp stm32.h stm429.cpp stm429.h Timer4XX.cpp Timer4XX.h
  group Utils
    ../Panel/src/Utils/: Decoder.cpp Decoder.h Math.cpp Math.h
  group Settings
    ../Panel/src/Settings/: Settings.cpp SettingsTypes.h Settings.h
