# Keil uVision project PanelOSC.uvprojx, settings and files
target PanelOSC (6070000::V6.7::.\ARMCLANG)
  device: STM32F429VITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: PanelOSC
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx
  c include: .\src;.\src\libs\CMSIS;.\src\libs\HAL;..\libs\common;..\libs\STM32Cube_F4\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\libs\STM32Cube_F4\Drivers\STM32F4xx_HAL_Driver\Inc;..\libs\STM32Cube_F4\Drivers\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group libs/CMSIS
    ./src/libs/CMSIS/: startup_stm32f429xx.s system_stm32f4xx.c
    ../libs/STM32Cube_F4/Drivers/CMSIS/Device/ST/STM32F4xx/Include/: stm32f4xx.h stm32f429xx.h
  group libs/HAL
    ../libs/STM32Cube_F4/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_gpio.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_dma2d.c
    ../libs/STM32Cube_F4/Drivers/STM32F4xx_HAL_Driver/Inc/: stm32f4xx_hal.h stm32f4xx_hal_cortex.h stm32f4xx_hal_dma.h stm32f4xx_hal_gpio.h stm32f4xx_hal_tim.h stm32f4xx_hal_tim_ex.h stm32f4xx_hal_pwr.h stm32f4xx_hal_pwr_ex.h stm32f4xx_hal_rcc.h stm32f4xx_hal_rtc_ex.h stm32f4xx_hal_ltdc.h stm32f4xx_hal_dma2d.h
    ./src/libs/HAL/: stm32f4xx_hal_conf.h stm32f4xx_hal_msp.c stm32f4xx_it.c stm32f4xx_it.h
  group src
    ./src/: main.cpp defines.h
  group Display
    ./src/Display/: Display.cpp Display.h Painter.cpp Painter.h DisplayTypes.h
  group Display/font
    ./src/Display/font/: Font.h font5.inc font8.inc fontUGO.inc fontUGO2.inc Font.cpp
  group Hardware
    ./src/Hardware/: FSMC.cpp Hardware.cpp Timer.cpp FSMC.h Hardware.h Timer.h Decoder.cpp Decoder.h CPU.cpp CPU.h CPU_IT.cpp
  group Hardware/stm32
    ../libs/common/Hardware/stm32/: stm32.cpp stm32.h stm32_it.cpp
    ../libs/common/Hardware/stm32/4XX/: stm429.cpp stm429.h
  group Keyboard
    ./src/Keyboard/: Keyboard.cpp Keyboard.h Controls.h
